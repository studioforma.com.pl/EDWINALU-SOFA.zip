Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Edwin Alu-Sofa - ver4.ifc
Time: 2025-11-26T15:49:00
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (12)
Name
 | Edwin Alu-Sofa_0 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_1 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_2 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_3 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_4 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_5 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_6 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_7 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_8 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_9 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_10 - ObjectType: SketchupGroup
 | Edwin Alu-Sofa_11 - ObjectType: SketchupGroup
